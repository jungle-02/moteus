# Keil uVision project moteus_keil.uvprojx, settings and files
target Target_1 (ARM-ADS)
  device: STM32G474CEUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: moteus_keil
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ../fw/: aksim2.h as5047.h aux_adc.h aux_common.h aux_mbed.h aux_port.h bldc_servo.h bldc_servo_position.h bldc_servo_structs.h board_debug.h bootloader.h ccm.h clock_manager.h cui_amt21.h cui_amt22.h drv8323.h error.h fdcan.h fdcan_micro_server.h firmware_info.h foc.h git_info.h ic_pz.h ma732.h math.h measured_hw_rev.h millisecond_timer.h moteus_controller.h moteus_hw.h motor_driver.h motor_position.h pid.h simple_pi.h simple_pid.h stm32.h stm32_bitbang_spi.h stm32_digital_monitor.h stm32_digital_output.h stm32_dma.h stm32_gpio_interrupt_in.h stm32_i2c.h stm32_i2c_timing.h stm32_serial.h stm32_spi.h stm32g4_adc.h stm32g4_async_uart.h stm32g4_dma_uart.h stm32g4_flash.h stm32g4xx_fdcan_typedefs.h stream_writer.h strtof.h system_info.h thermistor.h torque_model.h uuid.h bldc_servo.cc board_debug.cc can_bootloader.cc drv8323.cc error.cc fdcan.cc firmware_info.cc foc.cc git_info.cc git_info_linkstamp.cc moteus.cc moteus_assert.cc moteus_controller.cc moteus_hardfault_handler.cc moteus_hw.cc multiplex_tool_main.cc stm32_gpio_interrupt_in.cc stm32_serial.cc stm32g4_adc.cc stm32g4_async_uart.cc system_info.cc uuid.cc
